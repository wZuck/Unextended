## firmware/config/boards/shields/unextended_ec/Kconfig.defconfig
```kconfig
if SHIELD_UnextendedEC
config ZMK_KEYBOARD_NAME
    default "UnextendedEC"
endif
```
